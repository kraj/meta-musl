FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://musl-fixes.patch"
