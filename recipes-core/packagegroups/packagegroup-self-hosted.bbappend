RDEPENDS_packagegroup-self-hosted-sdk_remove = "glibc-gconv-ibm850"
