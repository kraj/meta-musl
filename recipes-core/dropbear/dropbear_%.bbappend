EXTRA_OECONF_append_libc-musl = " --disable-wtmp"
