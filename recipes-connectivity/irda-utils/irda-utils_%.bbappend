TARGETS_libc-musl = "irattach"
