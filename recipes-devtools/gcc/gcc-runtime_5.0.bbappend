require recipes-devtools/gcc/gcc-musl.inc

