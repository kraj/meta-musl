COMPATIBLE_HOST_libc-musl = "(none)"
require recipes-devtools/gcc/gcc-musl.inc

