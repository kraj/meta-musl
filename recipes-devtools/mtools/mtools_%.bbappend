RDEPENDS_${PN}_remove = "glibc-gconv-ibm850"

RRECOMMENDS_${PN}_remove = "\
        glibc-gconv-ibm437 \
        glibc-gconv-ibm737 \
        glibc-gconv-ibm775 \
        glibc-gconv-ibm851 \
        glibc-gconv-ibm852 \
        glibc-gconv-ibm855 \
        glibc-gconv-ibm857 \
        glibc-gconv-ibm860 \
        glibc-gconv-ibm861 \
        glibc-gconv-ibm862 \
        glibc-gconv-ibm863 \
        glibc-gconv-ibm865 \
        glibc-gconv-ibm866 \
        glibc-gconv-ibm869 \
        "
