
FILESEXTRAPATHS_prepend := "${THISDIR}/${BPN}:"

SRC_URI += "file://try-asm-sgidefs.h-as-well-as-sigmips.h.patch"
